# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c rc522.h rc522.c main.h
  group mybsp
    ./mybsp/: adc.c adc.h display.c display.h key.c key.h regdef.h sys.c sys.h uart1.c uart1.h
    ./: main.h AT24C02.h AT24C02.c
